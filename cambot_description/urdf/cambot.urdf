Commit message: edit proper mass value

File: cambot_description/urdf/cambot.urdf (robot description, URDF)
Before this commit: robot cambot, 6 links, 5 joints
Links:
- link link2: mass 0.0 -> 1.0
